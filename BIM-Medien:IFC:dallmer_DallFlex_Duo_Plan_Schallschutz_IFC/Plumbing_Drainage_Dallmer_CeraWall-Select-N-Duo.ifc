Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-02-07T15:51:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160512_1515(x64) - Exporter 2015.0.2016.0512 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 07 15:51:59 2019 * Host: WALTER-IRNES * Database: C:\Users\user\AppData\Local\Temp\{5AA538E7-B374-4597-B938-FF6700D39027}\ifc * Database version: 5507 * Database creation date: Thu Feb 07 15:51:57 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 07 15:51:58 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 07 15:51:58 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: CeraWall Select N Duo 1300mm (3)
In: Level 0
Classification: D2030300 Floor Drains (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Dallmer
Pset_DistributionFlowElementCommon - Reference: CeraWall Select N Duo 1300mm
Constraints - Leg Warning Visiblity: no; Length Warning Visiblity: no; Level: Level: Level 0
Construction - Article Number Shower Channel: 536181; Fire Protection System: no; Outlet Angle: 0 deg; Outlet Position: Concentric; Shower Channel Finish: satin stainess steel; Sound Insulation: no
Dimensions - Floor Finish Thickness: 30 mm; Leg Height: 90 mm; Suitable for Floor Finish: 24-32mm; Length: 1300 mm
Graphics - Symbolic Representation: yes
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Plumbing_Drainage_Dallmer_CeraWall-Select-N-Duo: CeraWall Select N Duo 1300mm; Family and Type: Plumbing_Drainage_Dallmer_CeraWall-Select-N-Duo: CeraWall Select N Duo 1300mm; Host Id: Floor: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; Type: Plumbing_Drainage_Dallmer_CeraWall-Select-N-Duo: CeraWall Select N Duo 1300mm; Type Id: Plumbing_Drainage_Dallmer_CeraWall-Select-N-Duo: CeraWall Select N Duo 1300mm; Family Name: Plumbing_Drainage_Dallmer_CeraWall-Select-N-Duo
Phasing - Phase Created: New Construction
General - Brand url: http://www.dallmer.com/en/; Design country: Germany; Edition number: 1; Manufacturer country: Germany; Manufacturer name: Dallmer; Nominal height: 0; Nominal width: 0; Product family: Shower channel; Product group: DallFlex; Product SKU: shower-channels-cerawall-select-n-duo-536815536723; QR code: http://bimobject.com/dallmer/product/shower-channels-cerawall-select-n-duo-536815536723; Region Africa: AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; Region Antarctica: BV, GS, HM, TF; Region Asia: AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Region Middle East: AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; Region North America: AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; Region Oceania: AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; Region South America: AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; Weight Net (Kg): 0
Identity Data - Assembly Code: D2030300; Assembly Description: Floor Drains; Description: Shower Channel; Installation instructions: http://www.dallmer.de/wAssets/docs/de/montageanleitungen/Montageanleitung-348535245.pdf; Keynote: 15150.A2; Manufacturer: Dallmer; Model: CeraWall Select N Duo; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Product data url: https://bimobject.com/dallmer/product/shower-channels-cerawall-select-n-duo-536815536723; Product url: http://www.dallmer.de/wAssets/docs/de/pdb/dallmer_536815.pdf; Type Name: CeraWall Select N Duo 1300mm; URL: http://www.dallmer.com/en/; Youtube clip: https://www.youtube.com/embed/m9WBw4x9uDA?rel=0&autoplay=1&viewmode=blank
Materials and Finishes - Material main: Stainless steel; Material secondary: Polypropylene
Name (Plumbing_Drainage_Dallmer_CeraWall-Select-N-Duo:CeraWall Select N Duo 1300mm:...) | Material | Article Number Drain Body | Article Number Fire Protection | Drain Body Type | Area (m2) | Drain Body Height (mm) | Leg Height Available | Pipe Diameter (mm) | Volume (m3) | Mark | Flow Rate (m3/s)
314793 | Steel - Dallmer - DallFlex - Black, Plastic - Dallmer - DallFlex - Black, Plastic - Dallmer - DallFlex - Blue, Stainless Steel - Dallmer - DallFlex - Satin, PVC - Dallmer - Piping, Plastic - Dallmer - DallFlex - Gray, Plastic - Dallmer - DallFlex - White | 536501 | Not available for selected Drain body type | Plan DN 40 | 1.47011 | 65 | 65<Leg Height<143 | 40 | 0.017153 | 19 | 0.00086
314833 | Steel - Dallmer - DallFlex - Black, Plastic - Dallmer - DallFlex - Black, Plastic - Dallmer - DallFlex - Blue, Stainless Steel - Dallmer - DallFlex - Satin, PVC - Dallmer - Piping, Plastic - Dallmer - DallFlex - Gray, Plastic - Dallmer - DallFlex - White | 536006 | Not available for selected Drain body type | DN 50 | 1.29728 | 90 | 90<Leg Height<143 | 50 | 0.0119872 | 20 | 0.00145
314850 | Plastic - Dallmer - DallFlex - Black, Steel - Dallmer - DallFlex - Black, Plastic - Dallmer - DallFlex - Blue, Stainless Steel - Dallmer - DallFlex - Satin, PVC - Dallmer - Piping, Plastic - Dallmer - DallFlex - Gray | 539083 |  | Vertical DN 50 | 1.24491 | 30 | 30<Leg Height<143 | 50 | 0.011894 | 21 | 0.00235 | Construction - Article Number Sound Insulation: Sound insulation not available for selected drain body type
